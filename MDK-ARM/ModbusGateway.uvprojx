# Keil uVision project ModbusGateway.uvprojx, settings and files
target ModbusGateway (6190000::V6.19::ARMCLANG)
  device: STM32F103RG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(72000000)
  output: ModbusGateway +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xG
  c misc: -fno-strict-aliasing
  c include: .\Inc;.\App\Inc;.\App\Config;.\App\CH395;.\App\Web
  asm define: USE_HAL_DRIVER STM32F103xG
  group App/Src
    ./App/Src/: user.c rs485.c utils.c log_uart.c data_pool.c modbus_master.c modbus_slave.c modbus_tcp.c isapi_client.c web_server.c config_storage.c tasks.c
  group App/Config
    ./App/Config/: config.c
  group App/CH395
    ./App/CH395/: ch395_drv.c
  group App/Web
    ./App/Web/: web_resources.c
  group Core/Src
    ./Src/: main.c stm32f1xx_it.c system_stm32f1xx.c
  group MDK-ARM
    ./MDK-ARM/: startup_stm32f103xg.s
